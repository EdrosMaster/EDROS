# Keil uVision project Application.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Application
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32G071XX
  c include: ..\Xternals\CMSIS;..\Xternals\STM32G0xx\Include;..\System\Kernel;..\System\Drivers\STM32G070;..\System\Internals;..\System\Classes\Peripherals;..\System\Classes\Parts
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000400 size 0x9000
  group Application
    ../Application/: Example_1.cpp Example_1.h
  group EDROS
    ../System/Kernel/: Kernel.lib
    ../System/Internals/: Internals.lib
    ../System/Drivers/STM32G070/: Drivers.lib
  group Startup
    ../Xternals/STM32G0xx/Source/Templates/: system_stm32g0xx.c
    ../Xternals/STM32G0xx/Source/Templates/arm/: startup_stm32g071xx.s
  group Parts
    ../System/Classes/Parts/: Parts.lib NLed.h NSwitch.h
  group Peripherals
    ../System/Classes/Peripherals/: Peripherals.lib NAdc.h NDac.h NHardTimer.h NIic.h NInput.h NLowPowerTimer.h NOutput.h NPwm.h NSerial.h NSpi.h NTinyOutput.h
